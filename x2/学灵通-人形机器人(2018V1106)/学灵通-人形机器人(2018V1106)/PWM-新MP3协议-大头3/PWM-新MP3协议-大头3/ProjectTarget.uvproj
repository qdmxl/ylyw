# Keil uVision project ProjectTarget.uvproj, settings and files
target ProjectTarget (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: ProjectTarget +hex
  c flags: Optimize=8 SizeSpeed=1
  group C_Files
    ./: main.c delay.c tuxinghua.c adc.c BUZZ.c basal.c walking.c jiewu.c ticao.c qianshou.c qiaoxiyang.c HT1621.c
  group H_Files
    ./: REG15W4Kxx.h USART.h CH376INC.h CH376DO.h delay.h tuxinghua.h SdCard.h adc.h BUZZ.h basal.h main.h walking.h jiewu.h ticao.h qianshou.h qiaoxiyang.h PSX.h HT1621.h
